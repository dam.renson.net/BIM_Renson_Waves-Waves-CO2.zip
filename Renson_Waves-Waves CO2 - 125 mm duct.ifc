Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: 0001
Time: 2024-09-24T14:11:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 24 14:11:50 2024 * Host: RENSON-PC64rjMe * Database: C:\Users\naniw\AppData\Local\Temp\f3eba1f0-d95b-4dc5-91ce-eb76ea2635a1\93ca3117-d43f-4e64-9e4b-f6686b46bc12\ifc * Database version: 5507 * Database creation date: Tue Sep 24 14:11:41 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Sep 24 14:11:41 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 24 14:11:41 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 8mm Head

# IfcAirTerminal: Waves - Duct Connection 125 mm, Renson_Waves CO2 - 125 mm duct:Waves - Duct Connection 125 mm:347362
In: Level 1
Type - Classification: 66000004 (Uniformat); Material: RAL 9010 - Helder wit, RAL 5022 - Nacht blauw
Type - Pset_AirTerminalTypeCommon - Reference: Waves - Duct Connection 125 mm
Type - Pset_EnvironmentalImpactIndicators - Reference: Waves - Duct Connection 125 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: RENSON
Pset_AirTerminalTypeCommon - sets with these values: 2
